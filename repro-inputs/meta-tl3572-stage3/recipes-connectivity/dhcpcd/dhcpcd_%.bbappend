SYSTEMD_AUTO_ENABLE:${PN}:tl3572-evm = "disable"

