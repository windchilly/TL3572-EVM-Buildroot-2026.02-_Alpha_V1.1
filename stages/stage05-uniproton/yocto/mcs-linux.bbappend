FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-mcs-rpmsg-tty-full-payload.patch"
